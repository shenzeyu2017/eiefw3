# IAR project anttt-SD3-SDK6_1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51822-QFAA NordicSemi nRF51822-QFAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NRF51
  ICCARM.CCIncludePath2: ..\bsp; ..\application; ..\nordic_sdk6_1_0; ..\nordic_sdk6_1_0\Include; ..\nordic_sdk6_1_0\Include\s310; ..\nordic_sdk6_1_0\Include\ble; ..\nordic_sdk6_1_0\Include\ble\ble_services; ..\nordic_sdk6_1_0\Include\ble\device_manager; ..\nordic_sdk6_1_0\Include\app_common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\bsp
  OBJCOPY.OOCOutputFile: anttt-SD3-SDK6_1.hex
  ILINK.IlinkOutputFile: anttt-SD3-SDK6_1.out
  ILINK.IlinkIcfFile: ..\bsp\nRF51422_QFAA.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group _BSP
    Debug/Exe/: anttt-SD3-SDK6_1.hex
    ../: exec.mac
    ../bsp/: nRF51422_QFAA.icf
    ../softdevice/: s310_nrf51422_1.0.0_softdevice.hex
  group _BSP/Include
    ../bsp/: ant_integration.h ble_integration.h bleperipheral.h configuration.h eief1_nrf51-01.h interrupts.h leds_eieF1_nRF51.h soc_integration.h utilities.h
    ../../../../../Desktop/nRF51422/bsp/: spi_master_eie.h
  group _BSP/Source
    ../bsp/: ant_integration.c ble_integration.c bleperipheral.c eief1_nrf51-01.c interrupts.c leds_eief1_nRF51.c soc_integration.c utilities.c
    ../../../../../Desktop/nRF51422/bsp/: spi_master_eie.c
  group _CMSIS
    ../cmsis/: core_cm0.h
  group _Nordic_SDK_6_1_0
    ../nordic_sdk6_1_0/: spi_master.c
  group _Nordic_SDK_6_1_0/Include
    ../nordic_sdk6_1_0/Include/s310/: ant_error.h ant_interface.h ant_parameters.h ble.h ble_gap.h ble_gatts.h ble_types.h nrf_sdm.h nrf_soc.h
    ../nordic_sdk6_1_0/Include/ble/: ble_advdata.h ble_advdata_parser.h
    ../nordic_sdk6_1_0/Include/: nordic_common.h nrf.h nrf51.h nrf51_bitfields.h nrf_assert.h nrf_delay.h nrf_gpio.h nrf_gpiote.h
  group _Nordic_SDK_6_1_0/Source
    ../nordic_sdk6_1_0/: ble_advdata.c ble_advdata_parser.c iar_startup_nrf51.s system_nrf51422.c
  group Application/Include
    ../../../../../Desktop/nRF51422/application/: anttt.h
    ../application/: bleperipheral_engenuics.h main.h typedefs.h
  group Application/Source
    ../../../../../Desktop/nRF51422/application/: anttt.c
    ../application/: bleperipheral_engenuics.c main.c
